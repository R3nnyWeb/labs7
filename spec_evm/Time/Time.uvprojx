# Keil uVision project Time.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Time
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LIBS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./LIBS/: lcdstring.c mlt_lcd.c
    ./: 5.c
software components: CMSIS:CORE 5.1.2, Device:Startup_MDR1986BE9x 1.3.1, Drivers:BKP 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1
